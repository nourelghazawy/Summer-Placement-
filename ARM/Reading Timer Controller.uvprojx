# Keil uVision project Reading Timer Controller.uvprojx, settings and files
target STM32 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Reading Timer Controller
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Low_Layer_Library;.\System_Files;.\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ./: stm32f4xx_it.c main.c
    ./Low_Layer_Library/: stm32f4xx_ll_utils.c
    ./System_Files/: system_stm32f4xx.c startup_stm32f401xe.s
software components: CMSIS:CORE 5.0.1
